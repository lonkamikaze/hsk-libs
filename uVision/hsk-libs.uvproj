# Keil uVision project hsk-libs.uvproj, settings and files
target HSK_LIBS (MCS-51)
  device: XC878CM-16FF Infineon
  cpu: IRAM(0-0xFF) XRAM(0xF000-0xFBFF) IROM(0-0xEFFF) IROM2(0xF000-0xFFFF) CLOCK(24000000) MOD517DP
  output: hsk_libs +hex
  c flags: Optimize=12 SizeSpeed=1
  c define: __xdata, __pdata, __idata
  c include: ..\gen
  link misc: REMOVEUNUSED
  group DOC
    ../src/doc/: examples mainpage.txt
  group MAIN
    ../src/: config.h main.c
  group HSK_ADC
    ../src/hsk_adc/: hsk_adc.c hsk_adc.h
  group HSK_BOOT
    ../src/hsk_boot/: hsk_boot.c hsk_boot.h startup.a51
  group HSK_CAN
    ../src/hsk_can/: hsk_can.c hsk_can.h
  group HSK_EX
    ../src/hsk_ex/: hsk_ex.c hsk_ex.h
  group HSK_FLASH
    ../src/hsk_flash/: hsk_flash.h hsk_flash.c
  group HSK_ICM7228
    ../src/hsk_icm7228/: hsk_icm7228.h hsk_icm7228.c
  group HSK_IO
    ../src/hsk_io/: hsk_io.h
  group HSK_ISR
    ../src/hsk_isr/: hsk_isr.c hsk_isr.h
  group HSK_PWC
    ../src/hsk_pwc/: hsk_pwc.c hsk_pwc.h
  group HSK_PWM
    ../src/hsk_pwm/: hsk_pwm.c hsk_pwm.h
  group HSK_TIMERS
    ../src/hsk_timers/: hsk_timer01.c hsk_timer01.h
  group HSK_WDT
    ../src/hsk_wdt/: hsk_wdt.h hsk_wdt.c
  group HSK_SSC
    ../src/hsk_ssc/: hsk_ssc.h hsk_ssc.c
